<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\blink\blink.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\hello_world\serial\hello_serial.ewp</path>
    </project>
    <batchBuild />
</workspace>
