<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\blink\blink.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\hello_world\serial\hello_serial.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\hello_world\usb\hello_usb.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\adc\adc_console\adc_console.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\adc\dma_capture\adc_dma_capture.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\adc\hello_adc\hello_adc.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\adc\joystick_display\joystick_display.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\adc\onboard_temperature\onboard_temperature.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\adc\microphone_adc\microphone_adc.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\clocks\detached_clk_peri\clocks_detached_clk_peri.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\clocks\hello_48MHz\hello_48MHz.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\clocks\hello_gpout\hello_gpout.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\clocks\hello_resus\hello_resus.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\cmake\build_variants\build_variant1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\cmake\build_variants\build_variant2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\divider\hello_divider.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\dma\channel_irq\dma_channel_irq.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\dma\control_blocks\dma_control_blocks.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\dma\hello_dma\hello_dma.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\flash\cache_perfctr\flash_cache_perfctr.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\flash\nuke\flash_nuke.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\flash\program\flash_program.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\flash\ssi_dma\flash_ssi_dma.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\flash\xip_stream\flash_xip_stream.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\gpio\dht_sensor\dht.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\gpio\hello_7segment\hello_7segment.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\gpio\hello_gpio_irq\hello_gpio_irq.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\i2c\bmp280_i2c\bmp280_i2c.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\i2c\bus_scan\i2c_bus_scan.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\i2c\lcd_1602_i2c\lcd_1602_i2c.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\i2c\lis3dh_i2c\lis3dh_i2c.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\i2c\mcp9808_i2c\mcp9808_i2c.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\i2c\mma8451_i2c\mma8451_i2c.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\i2c\mpl3115a2_i2c\mpl3115a2_i2c.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\i2c\mpu6050_i2c\mpu6050_i2c.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\i2c\oled_i2c\oled_i2c.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\i2c\pa1010d_i2c\pa1010d_i2c.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\i2c\pcf8523_i2c\pcf8523_i2c.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\interp\hello_interp\hello_interp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\multicore\hello_multicore\hello_multicore.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\multicore\multicore_fifo_irqs\multicore_fifo_irqs.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\multicore\multicore_runner\multicore_runner.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\multicore\multicore_runner_queue\multicore_runner_queue.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\picoboard\blinky\picoboard_blinky.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\picoboard\button\picoboard_button.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\addition\pio_addition.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\apa102\pio_apa102.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\clocked_input\pio_clocked_input.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\differential_manchester\pio_differential_manchester.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\hello_pio\hello_pio.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\hub75\pio_hub75.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\i2c\pio_i2c_bus_scan.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\ir_nec\nec_transmit_library\nec_transmit_library.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\ir_nec\nec_receive_library\nec_receive_library.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\ir_nec\ir_loopback\pio_ir_loopback.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\logic_analyser\pio_logic_analyser.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\manchester_encoding\pio_manchester_encoding.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\pio_blink\pio_blink.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\pwm\pio_pwm.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\quadrature_encoder\pio_quadrature_encoder.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\spi\pio_spi_flash.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\spi\pio_spi_loopback.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\squarewave\pio_squarewave.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\st7789_lcd\pio_st7789_lcd.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\uart_rx\pio_uart_rx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\uart_tx\pio_uart_tx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\ws2812\pio_ws2812_parallel.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pio\ws2812\pio_ws2812.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pwm\hello_pwm\hello_pwm.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pwm\led_fade\pwm_led_fade.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\pwm\measure_duty_cycle\pwm_measure_duty_cycle.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\rtc\hello_rtc\hello_rtc.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\rtc\rtc_alarm\rtc_alarm.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\rtc\rtc_alarm_repeat\rtc_alarm_repeat.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\spi\bme280_spi\bme280_spi.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\spi\mpu9250_spi\mpu9250_spi.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\spi\spi_dma\spi_dma.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\spi\spi_master_slave\spi_master\spi_master.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\spi\spi_master_slave\spi_slave\spi_slave.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\spi\spi_flash\spi_flash.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\spi\max7219_32x8_spi\max7219_32x8_spi.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\spi\max7219_8x7seg_spi\max7219_8x7seg_spi.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\system\hello_double_tap\hello_double_tap.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\system\narrow_io_write\narrow_io_write.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\system\unique_board_id\unique_board_id.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\timer\hello_timer\hello_timer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\timer\periodic_sampler\periodic_sampler.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\timer\timer_lowlevel\timer_lowlevel.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\uart\hello_uart\hello_uart.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\uart\lcd_uart\lcd_uart.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\uart\uart_advanced\uart_advanced.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\audio_4_channel_mic\tinyusb_dev_audio_4_channel_mic.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\audio_test\tinyusb_dev_audio_test.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\board_test\tinyusb_dev_board_test.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\cdc_dual_ports\tinyusb_dev_cdc_dual_ports.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\cdc_msc\tinyusb_dev_cdc_msc.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\dfu\tinyusb_dev_dfu.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\dfu_runtime\tinyusb_dev_dfu_runtime.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\dynamic_configuration\tinyusb_dev_dynamic_configuration.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\hid_composite\tinyusb_dev_hid_composite.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\hid_generic_inout\tinyusb_dev_hid_generic_inout.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\hid_multiple_interface\tinyusb_dev_hid_multiple_interface.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\midi_test\tinyusb_dev_midi_test.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\msc_dual_lun\tinyusb_dev_msc_dual_lun.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\uac2_headset\tinyusb_dev_uac2_headset.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\usbtmc\tinyusb_dev_usbtmc.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\video_capture\tinyusb_dev_video_capture.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\tinyusb_device_examples\webusb_serial\tinyusb_dev_webusb_serial.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\dev_hid_composite\dev_hid_composite.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\device\dev_lowlevel\dev_lowlevel.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\host\tinyusb_host_examples\cdc_msc_hid\tinyusb_host_cdc_msc_hid.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\host\tinyusb_host_examples\hid_controller\tinyusb_host_hid_controller.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\usb\host\host_cdc_msc_hid\host_cdc_msc_hid.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\watchdog\hello_watchdog\hello_watchdog.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All - Debug</name>
            <member>
                <project>nec_transmit_library</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>nec_receive_library</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>blink</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_serial</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_usb</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>adc_console</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>adc_dma_capture</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_adc</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>joystick_display</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>onboard_temperature</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>microphone_adc</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>clocks_detached_clk_peri</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_48MHz</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_gpout</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_resus</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>build_variant1</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>build_variant2</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_divider</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>dma_channel_irq</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>dma_control_blocks</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_dma</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>flash_cache_perfctr</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>flash_nuke</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>flash_program</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>flash_ssi_dma</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>flash_xip_stream</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>dht</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_7segment</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_gpio_irq</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>bmp280_i2c</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>i2c_bus_scan</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>lcd_1602_i2c</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>lis3dh_i2c</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>mcp9808_i2c</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>mma8451_i2c</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>mpl3115a2_i2c</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>mpu6050_i2c</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>oled_i2c</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pa1010d_i2c</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pcf8523_i2c</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_interp</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_multicore</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>multicore_fifo_irqs</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>multicore_runner</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>multicore_runner_queue</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>picoboard_blinky</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>picoboard_button</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_addition</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_apa102</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_clocked_input</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_differential_manchester</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_pio</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_hub75</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_i2c_bus_scan</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_ir_loopback</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_logic_analyser</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_manchester_encoding</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_blink</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_pwm</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_quadrature_encoder</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_spi_flash</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_spi_loopback</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_squarewave</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_st7789_lcd</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_uart_rx</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_uart_tx</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_ws2812_parallel</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pio_ws2812</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_pwm</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pwm_led_fade</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pwm_measure_duty_cycle</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_rtc</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>rtc_alarm</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>rtc_alarm_repeat</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>bme280_spi</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>mpu9250_spi</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>spi_dma</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>spi_master</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>spi_slave</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>spi_flash</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>max7219_32x8_spi</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>max7219_8x7seg_spi</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_double_tap</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>narrow_io_write</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>unique_board_id</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_timer</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>periodic_sampler</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>timer_lowlevel</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_uart</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>lcd_uart</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>uart_advanced</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_audio_4_channel_mic</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_audio_test</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_board_test</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_cdc_dual_ports</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_cdc_msc</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_dfu</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_dfu_runtime</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_dynamic_configuration</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_hid_composite</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_hid_generic_inout</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_hid_multiple_interface</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_midi_test</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_msc_dual_lun</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_uac2_headset</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_usbtmc</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_video_capture</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_dev_webusb_serial</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>dev_hid_composite</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>dev_lowlevel</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_host_cdc_msc_hid</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tinyusb_host_hid_controller</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>host_cdc_msc_hid</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>hello_watchdog</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All - MinSizeRel</name>
            <member>
                <project>nec_transmit_library</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>nec_receive_library</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>blink</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_serial</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_usb</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>adc_console</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>adc_dma_capture</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_adc</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>joystick_display</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>onboard_temperature</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>microphone_adc</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>clocks_detached_clk_peri</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_48MHz</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_gpout</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_resus</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>build_variant1</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>build_variant2</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_divider</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>dma_channel_irq</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>dma_control_blocks</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_dma</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>flash_cache_perfctr</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>flash_nuke</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>flash_program</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>flash_ssi_dma</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>flash_xip_stream</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>dht</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_7segment</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_gpio_irq</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>bmp280_i2c</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>i2c_bus_scan</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>lcd_1602_i2c</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>lis3dh_i2c</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>mcp9808_i2c</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>mma8451_i2c</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>mpl3115a2_i2c</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>mpu6050_i2c</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>oled_i2c</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pa1010d_i2c</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pcf8523_i2c</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_interp</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_multicore</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>multicore_fifo_irqs</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>multicore_runner</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>multicore_runner_queue</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>picoboard_blinky</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>picoboard_button</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_addition</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_apa102</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_clocked_input</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_differential_manchester</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_pio</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_hub75</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_i2c_bus_scan</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_ir_loopback</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_logic_analyser</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_manchester_encoding</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_blink</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_pwm</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_quadrature_encoder</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_spi_flash</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_spi_loopback</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_squarewave</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_st7789_lcd</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_uart_rx</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_uart_tx</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_ws2812_parallel</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pio_ws2812</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_pwm</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pwm_led_fade</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>pwm_measure_duty_cycle</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_rtc</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>rtc_alarm</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>rtc_alarm_repeat</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>bme280_spi</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>mpu9250_spi</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>spi_dma</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>spi_master</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>spi_slave</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>spi_flash</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>max7219_32x8_spi</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>max7219_8x7seg_spi</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_double_tap</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>narrow_io_write</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>unique_board_id</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_timer</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>periodic_sampler</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>timer_lowlevel</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_uart</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>lcd_uart</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>uart_advanced</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_audio_4_channel_mic</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_audio_test</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_board_test</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_cdc_dual_ports</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_cdc_msc</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_dfu</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_dfu_runtime</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_dynamic_configuration</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_hid_composite</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_hid_generic_inout</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_hid_multiple_interface</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_midi_test</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_msc_dual_lun</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_uac2_headset</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_usbtmc</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_video_capture</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_dev_webusb_serial</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>dev_hid_composite</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>dev_lowlevel</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_host_cdc_msc_hid</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>tinyusb_host_hid_controller</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>host_cdc_msc_hid</project>
                <configuration>MinSizeRel</configuration>
            </member>
            <member>
                <project>hello_watchdog</project>
                <configuration>MinSizeRel</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All - RelWithDebInfo</name>
            <member>
                <project>nec_transmit_library</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>nec_receive_library</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>blink</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_serial</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_usb</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>adc_console</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>adc_dma_capture</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_adc</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>joystick_display</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>onboard_temperature</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>microphone_adc</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>clocks_detached_clk_peri</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_48MHz</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_gpout</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_resus</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>build_variant1</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>build_variant2</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_divider</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>dma_channel_irq</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>dma_control_blocks</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_dma</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>flash_cache_perfctr</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>flash_nuke</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>flash_program</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>flash_ssi_dma</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>flash_xip_stream</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>dht</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_7segment</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_gpio_irq</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>bmp280_i2c</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>i2c_bus_scan</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>lcd_1602_i2c</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>lis3dh_i2c</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>mcp9808_i2c</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>mma8451_i2c</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>mpl3115a2_i2c</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>mpu6050_i2c</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>oled_i2c</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pa1010d_i2c</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pcf8523_i2c</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_interp</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_multicore</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>multicore_fifo_irqs</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>multicore_runner</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>multicore_runner_queue</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>picoboard_blinky</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>picoboard_button</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_addition</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_apa102</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_clocked_input</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_differential_manchester</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_pio</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_hub75</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_i2c_bus_scan</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_ir_loopback</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_logic_analyser</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_manchester_encoding</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_blink</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_pwm</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_quadrature_encoder</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_spi_flash</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_spi_loopback</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_squarewave</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_st7789_lcd</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_uart_rx</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_uart_tx</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_ws2812_parallel</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pio_ws2812</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_pwm</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pwm_led_fade</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>pwm_measure_duty_cycle</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_rtc</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>rtc_alarm</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>rtc_alarm_repeat</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>bme280_spi</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>mpu9250_spi</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>spi_dma</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>spi_master</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>spi_slave</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>spi_flash</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>max7219_32x8_spi</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>max7219_8x7seg_spi</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_double_tap</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>narrow_io_write</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>unique_board_id</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_timer</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>periodic_sampler</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>timer_lowlevel</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_uart</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>lcd_uart</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>uart_advanced</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_audio_4_channel_mic</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_audio_test</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_board_test</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_cdc_dual_ports</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_cdc_msc</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_dfu</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_dfu_runtime</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_dynamic_configuration</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_hid_composite</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_hid_generic_inout</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_hid_multiple_interface</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_midi_test</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_msc_dual_lun</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_uac2_headset</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_usbtmc</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_video_capture</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_dev_webusb_serial</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>dev_hid_composite</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>dev_lowlevel</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_host_cdc_msc_hid</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>tinyusb_host_hid_controller</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>host_cdc_msc_hid</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
            <member>
                <project>hello_watchdog</project>
                <configuration>RelWithDebInfo</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All - Release</name>
            <member>
                <project>nec_transmit_library</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>nec_receive_library</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>blink</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_serial</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_usb</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>adc_console</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>adc_dma_capture</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_adc</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>joystick_display</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>onboard_temperature</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>microphone_adc</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>clocks_detached_clk_peri</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_48MHz</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_gpout</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_resus</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>build_variant1</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>build_variant2</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_divider</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>dma_channel_irq</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>dma_control_blocks</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_dma</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>flash_cache_perfctr</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>flash_nuke</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>flash_program</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>flash_ssi_dma</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>flash_xip_stream</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>dht</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_7segment</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_gpio_irq</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>bmp280_i2c</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>i2c_bus_scan</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>lcd_1602_i2c</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>lis3dh_i2c</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mcp9808_i2c</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mma8451_i2c</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mpl3115a2_i2c</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mpu6050_i2c</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>oled_i2c</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pa1010d_i2c</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pcf8523_i2c</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_interp</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_multicore</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>multicore_fifo_irqs</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>multicore_runner</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>multicore_runner_queue</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>picoboard_blinky</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>picoboard_button</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_addition</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_apa102</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_clocked_input</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_differential_manchester</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_pio</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_hub75</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_i2c_bus_scan</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_ir_loopback</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_logic_analyser</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_manchester_encoding</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_blink</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_pwm</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_quadrature_encoder</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_spi_flash</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_spi_loopback</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_squarewave</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_st7789_lcd</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_uart_rx</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_uart_tx</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_ws2812_parallel</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pio_ws2812</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_pwm</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pwm_led_fade</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>pwm_measure_duty_cycle</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_rtc</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>rtc_alarm</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>rtc_alarm_repeat</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>bme280_spi</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mpu9250_spi</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>spi_dma</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>spi_master</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>spi_slave</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>spi_flash</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>max7219_32x8_spi</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>max7219_8x7seg_spi</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_double_tap</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>narrow_io_write</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>unique_board_id</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_timer</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>periodic_sampler</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>timer_lowlevel</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_uart</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>lcd_uart</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>uart_advanced</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_audio_4_channel_mic</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_audio_test</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_board_test</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_cdc_dual_ports</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_cdc_msc</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_dfu</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_dfu_runtime</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_dynamic_configuration</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_hid_composite</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_hid_generic_inout</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_hid_multiple_interface</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_midi_test</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_msc_dual_lun</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_uac2_headset</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_usbtmc</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_video_capture</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_dev_webusb_serial</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>dev_hid_composite</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>dev_lowlevel</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_host_cdc_msc_hid</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>tinyusb_host_hid_controller</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>host_cdc_msc_hid</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>hello_watchdog</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
