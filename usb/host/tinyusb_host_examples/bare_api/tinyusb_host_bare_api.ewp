# IAR project tinyusb_host_bare_api.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: RP2040 RaspberryPi RP2040
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CFG_TUSB_MCU=OPT_MCU_RP2040; CFG_TUSB_OS=OPT_OS_PICO; LIB_BOOT_STAGE2=1; LIB_PICO_BIT_OPS=1; LIB_PICO_BIT_OPS_PICO=1; LIB_PICO_BOOTSEL_VIA_DOUBLE_RESET=1; LIB_PICO_DIVIDER=1; LIB_PICO_DIVIDER_HARDWARE=1; LIB_PICO_DOUBLE=1; LIB_PICO_DOUBLE_PICO=1; LIB_PICO_FLOAT=1; LIB_PICO_FLOAT_PICO=1; LIB_PICO_INT64_OPS=1; LIB_PICO_INT64_OPS_PICO=1; LIB_PICO_MALLOC=1; LIB_PICO_MEM_OPS=1; LIB_PICO_MEM_OPS_PICO=1; LIB_PICO_PLATFORM=1; LIB_PICO_PRINTF=1; LIB_PICO_PRINTF_PICO=1; LIB_PICO_RUNTIME=1; LIB_PICO_STANDARD_LINK=1; LIB_PICO_STDIO=1; LIB_PICO_STDIO_UART=1; LIB_PICO_STDLIB=1; LIB_PICO_SYNC=1; LIB_PICO_SYNC_CRITICAL_SECTION=1; LIB_PICO_SYNC_MUTEX=1; LIB_PICO_SYNC_SEM=1; LIB_PICO_TIME=1; LIB_PICO_UTIL=1; LIB_TINYUSB_BOARD=1; LIB_TINYUSB_HOST=1; PICO_BOARD="pico"; PICO_BUILD=1; PICO_CMAKE_BUILD_TYPE="Release"; PICO_COPY_TO_RAM=0; PICO_CXX_ENABLE_EXCEPTIONS=0; PICO_NO_FLASH=0; PICO_NO_HARDWARE=0; PICO_ON_DEVICE=1; PICO_RP2040_USB_DEVICE_ENUMERATION_FIX=1; PICO_RP2040_USB_DEVICE_UFRAME_FIX=1; PICO_TARGET_NAME="tinyusb_host_bare_api"; PICO_USE_BLOCKED_RAM=0; RP2040_USB_HOST_MODE=1
  ICCARM.CCDiagSuppress: Pa039,Pe170
  ICCARM.CCIncludePath2: ..\..\..\..\..\pico-sdk\lib\tinyusb\examples\host\bare_api\src; ..\..\..\..\..\pico-sdk\src\common\pico_stdlib\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_gpio\include; ..\..\..\..\..\pico-sdk\src\common\pico_base\include; ..\..\..\..\generated\pico_base; ..\..\..\..\..\pico-sdk\src\boards\include; ..\..\..\..\..\pico-sdk\src\rp2_common\pico_platform\include; ..\..\..\..\..\pico-sdk\src\rp2040\hardware_regs\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_base\include; ..\..\..\..\..\pico-sdk\src\rp2040\hardware_structs\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_claim\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_sync\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_irq\include; ..\..\..\..\..\pico-sdk\src\common\pico_sync\include; ..\..\..\..\..\pico-sdk\src\common\pico_time\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_timer\include; ..\..\..\..\..\pico-sdk\src\common\pico_util\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_uart\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_resets\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_clocks\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_pll\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_vreg\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_watchdog\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_xosc\include; ..\..\..\..\..\pico-sdk\src\rp2_common\hardware_divider\include; ..\..\..\..\..\pico-sdk\src\rp2_common\pico_runtime\include; ..\..\..\..\..\pico-sdk\src\rp2_common\pico_printf\include; ..\..\..\..\..\pico-sdk\src\common\pico_bit_ops\include; ..\..\..\..\..\pico-sdk\src\common\pico_divider\include; ..\..\..\..\..\pico-sdk\src\rp2_common\pico_double\include; ..\..\..\..\..\pico-sdk\src\rp2_common\pico_float\include; ..\..\..\..\..\pico-sdk\src\rp2_common\pico_malloc\include; ..\..\..\..\..\pico-sdk\src\rp2_common\pico_bootrom\include; ..\..\..\..\..\pico-sdk\src\common\pico_binary_info\include; ..\..\..\..\..\pico-sdk\src\rp2_common\pico_stdio\include; ..\..\..\..\..\pico-sdk\src\rp2_common\pico_stdio_uart\include; ..\..\..\..\..\pico-sdk\src\rp2_common\boot_stage2\include; ..\..\..\..\..\pico-sdk\src\rp2_common\boot_stage2\asminclude; ..\..\..\..\..\pico-sdk\src\rp2_common\pico_int64_ops\include; ..\..\..\..\..\pico-sdk\src\rp2_common\pico_mem_ops\include; ..\..\..\..\..\pico-sdk\lib\tinyusb\src; ..\..\..\..\..\pico-sdk\lib\tinyusb\src\common; ..\..\..\..\..\pico-sdk\lib\tinyusb\hw
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_host_bare_api.srec
  ILINK.IlinkOutputFile: tinyusb_host_bare_api.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: ..\..\..\..\..\pico-sdk\src\rp2_common\pico_standard_link\memmap_default.icf
  ILINK.IlinkProgramEntryLabel: _entry_point
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CFG_TUSB_MCU=OPT_MCU_RP2040; CFG_TUSB_OS=OPT_OS_PICO; LIB_BOOT_STAGE2=1; LIB_PICO_BIT_OPS=1; LIB_PICO_BIT_OPS_PICO=1; LIB_PICO_BOOTSEL_VIA_DOUBLE_RESET=1; LIB_PICO_DIVIDER=1; LIB_PICO_DIVIDER_HARDWARE=1; LIB_PICO_DOUBLE=1; LIB_PICO_DOUBLE_PICO=1; LIB_PICO_FLOAT=1; LIB_PICO_FLOAT_PICO=1; LIB_PICO_INT64_OPS=1; LIB_PICO_INT64_OPS_PICO=1; LIB_PICO_MALLOC=1; LIB_PICO_MEM_OPS=1; LIB_PICO_MEM_OPS_PICO=1; LIB_PICO_PLATFORM=1; LIB_PICO_PRINTF=1; LIB_PICO_PRINTF_PICO=1; LIB_PICO_RUNTIME=1; LIB_PICO_STANDARD_LINK=1; LIB_PICO_STDIO=1; LIB_PICO_STDIO_UART=1; LIB_PICO_STDLIB=1; LIB_PICO_SYNC=1; LIB_PICO_SYNC_CRITICAL_SECTION=1; LIB_PICO_SYNC_MUTEX=1; LIB_PICO_SYNC_SEM=1; LIB_PICO_TIME=1; LIB_PICO_UTIL=1; LIB_TINYUSB_BOARD=1; LIB_TINYUSB_HOST=1; NDEBUG; PICO_BOARD="pico"; PICO_BUILD=1; PICO_CMAKE_BUILD_TYPE="Release"; PICO_COPY_TO_RAM=0; PICO_CXX_ENABLE_EXCEPTIONS=0; PICO_NO_FLASH=0; PICO_NO_HARDWARE=0; PICO_ON_DEVICE=1; PICO_RP2040_USB_DEVICE_ENUMERATION_FIX=1; PICO_RP2040_USB_DEVICE_UFRAME_FIX=1; PICO_TARGET_NAME="tinyusb_host_bare_api"; PICO_USE_BLOCKED_RAM=0; RP2040_USB_HOST_MODE=1
  AARM.ADefines: as above
configuration MinSizeRel (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  AARM.ADefines: as above
configuration RelWithDebInfo (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  AARM.ADefines: as above
  group lib/tinyusb/examples/host/bare_api/src
    ../../../../../pico-sdk/lib/tinyusb/examples/host/bare_api/src/: main.c
  group lib/tinyusb/hw/bsp/rp2040
    ../../../../../pico-sdk/lib/tinyusb/hw/bsp/rp2040/: family.c
  group lib/tinyusb/src
    ../../../../../pico-sdk/lib/tinyusb/src/: tusb.c
  group lib/tinyusb/src/class/cdc
    ../../../../../pico-sdk/lib/tinyusb/src/class/cdc/: cdc_host.c
  group lib/tinyusb/src/class/hid
    ../../../../../pico-sdk/lib/tinyusb/src/class/hid/: hid_host.c
  group lib/tinyusb/src/class/msc
    ../../../../../pico-sdk/lib/tinyusb/src/class/msc/: msc_host.c
  group lib/tinyusb/src/class/vendor
    ../../../../../pico-sdk/lib/tinyusb/src/class/vendor/: vendor_host.c
  group lib/tinyusb/src/common
    ../../../../../pico-sdk/lib/tinyusb/src/common/: tusb_fifo.c
  group lib/tinyusb/src/host
    ../../../../../pico-sdk/lib/tinyusb/src/host/: hub.c usbh.c
  group lib/tinyusb/src/portable/raspberrypi/rp2040
    ../../../../../pico-sdk/lib/tinyusb/src/portable/raspberrypi/rp2040/: hcd_rp2040.c rp2040_usb.c
  group src/common/pico_sync
    ../../../../../pico-sdk/src/common/pico_sync/: critical_section.c lock_core.c mutex.c sem.c
  group src/common/pico_time
    ../../../../../pico-sdk/src/common/pico_time/: time.c timeout_helper.c
  group src/common/pico_util
    ../../../../../pico-sdk/src/common/pico_util/: datetime.c pheap.c queue.c
  group src/rp2_common/boot_stage2
    ../../../../../pico-sdk/src/rp2_common/boot_stage2/: compile_time_choice.S
  group src/rp2_common/hardware_claim
    ../../../../../pico-sdk/src/rp2_common/hardware_claim/: claim.c
  group src/rp2_common/hardware_clocks
    ../../../../../pico-sdk/src/rp2_common/hardware_clocks/: clocks.c
  group src/rp2_common/hardware_divider
    ../../../../../pico-sdk/src/rp2_common/hardware_divider/: divider.S
  group src/rp2_common/hardware_gpio
    ../../../../../pico-sdk/src/rp2_common/hardware_gpio/: gpio.c
  group src/rp2_common/hardware_irq
    ../../../../../pico-sdk/src/rp2_common/hardware_irq/: irq.c irq_handler_chain.S
  group src/rp2_common/hardware_pll
    ../../../../../pico-sdk/src/rp2_common/hardware_pll/: pll.c
  group src/rp2_common/hardware_sync
    ../../../../../pico-sdk/src/rp2_common/hardware_sync/: sync.c
  group src/rp2_common/hardware_timer
    ../../../../../pico-sdk/src/rp2_common/hardware_timer/: timer.c
  group src/rp2_common/hardware_uart
    ../../../../../pico-sdk/src/rp2_common/hardware_uart/: uart.c
  group src/rp2_common/hardware_vreg
    ../../../../../pico-sdk/src/rp2_common/hardware_vreg/: vreg.c
  group src/rp2_common/hardware_watchdog
    ../../../../../pico-sdk/src/rp2_common/hardware_watchdog/: watchdog.c
  group src/rp2_common/hardware_xosc
    ../../../../../pico-sdk/src/rp2_common/hardware_xosc/: xosc.c
  group src/rp2_common/pico_bit_ops
    ../../../../../pico-sdk/src/rp2_common/pico_bit_ops/: bit_ops_aeabi.S
  group src/rp2_common/pico_bootrom
    ../../../../../pico-sdk/src/rp2_common/pico_bootrom/: bootrom.c
  group src/rp2_common/pico_bootsel_via_double_reset
    ../../../../../pico-sdk/src/rp2_common/pico_bootsel_via_double_reset/: pico_bootsel_via_double_reset.c
  group src/rp2_common/pico_divider
    ../../../../../pico-sdk/src/rp2_common/pico_divider/: divider.S
  group src/rp2_common/pico_double
    ../../../../../pico-sdk/src/rp2_common/pico_double/: double_aeabi.S double_init_rom.c double_math.c double_v1_rom_shim.S
  group src/rp2_common/pico_float
    ../../../../../pico-sdk/src/rp2_common/pico_float/: float_aeabi.S float_init_rom.c float_math.c float_v1_rom_shim.S
  group src/rp2_common/pico_int64_ops
    ../../../../../pico-sdk/src/rp2_common/pico_int64_ops/: pico_int64_ops_aeabi.S
  group src/rp2_common/pico_malloc
    ../../../../../pico-sdk/src/rp2_common/pico_malloc/: pico_malloc_iar.c
  group src/rp2_common/pico_mem_ops
    ../../../../../pico-sdk/src/rp2_common/pico_mem_ops/: mem_ops_aeabi.S
  group src/rp2_common/pico_platform
    ../../../../../pico-sdk/src/rp2_common/pico_platform/: platform.c
  group src/rp2_common/pico_printf
    ../../../../../pico-sdk/src/rp2_common/pico_printf/: printf.c
  group src/rp2_common/pico_runtime
    ../../../../../pico-sdk/src/rp2_common/pico_runtime/: runtime.c
  group src/rp2_common/pico_standard_link
    ../../../../../pico-sdk/src/rp2_common/pico_standard_link/: binary_info.c crt0.S new_delete.cpp
  group src/rp2_common/pico_stdio
    ../../../../../pico-sdk/src/rp2_common/pico_stdio/: stdio.c
  group src/rp2_common/pico_stdio_uart
    ../../../../../pico-sdk/src/rp2_common/pico_stdio_uart/: stdio_uart.c
  group src/rp2_common/pico_stdlib
    ../../../../../pico-sdk/src/rp2_common/pico_stdlib/: stdlib.c
